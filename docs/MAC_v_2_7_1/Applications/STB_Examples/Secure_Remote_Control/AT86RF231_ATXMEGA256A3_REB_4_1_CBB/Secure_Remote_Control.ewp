# IAR project Secure_Remote_Control.ewp, settings and files
configuration Release (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x200
  General.SCRStackSize: 32
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-5s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3 ATxmega256A3
  ICCAVR.CCDefines: DEBUG=0; SIO_HUB; UART0; STB_ON_SAL; TAL_TYPE=AT86RF231; PAL_TYPE=ATXMEGA256A3; PAL_GENERIC_TYPE=XMEGA; BOARD_TYPE=REB_4_1_CBB; SAL_TYPE=ATXMEGA_SAL; HIGHEST_STACK_LAYER=TAL
  ICCAVR.newCCIncludePaths: ..\Inc; ..\..\..\Helper_Files\SIO_Support\Inc; ..\..\..\..\Include; ..\..\..\..\TAL\Inc; ..\..\..\..\TAL\AT86RF231\Inc; ..\..\..\..\PAL\Inc; ..\..\..\..\PAL\XMEGA\Generic\Inc; ..\..\..\..\PAL\XMEGA\ATXMEGA256A3\Inc; ..\..\..\..\PAL\XMEGA\ATXMEGA256A3\Boards; ..\..\..\..\PAL\XMEGA\ATXMEGA256A3\Boards\REB_4_1_CBB; ..\..\..\..\Resources\Buffer_Management\Inc; ..\..\..\..\Resources\Queue_Management\Inc; ..\..\..\..\SAL\Inc; ..\..\..\..\STB\Inc
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm256a3.xcl
configuration Debug (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: DEBUG=1; SIO_HUB; UART0; STB_ON_SAL; TAL_TYPE=AT86RF231; PAL_TYPE=ATXMEGA256A3; PAL_GENERIC_TYPE=XMEGA; BOARD_TYPE=REB_4_1_CBB; SAL_TYPE=ATXMEGA_SAL; HIGHEST_STACK_LAYER=TAL
  group (top)
    ../Src/: main.c
    ../../../Helper_Files/SIO_Support/Src/: sio_handler.c
    ../../../Helper_Files/SIO_Support/IAR_Support/: write.c
  group PAL
    ../../../../PAL/XMEGA/Generic/Src/: pal.c pal_timer.c pal_trx_access.c pal_uart.c pal_utils.c
    ../../../../PAL/XMEGA/ATXMEGA256A3/Src/: pal_sio_hub.c
  group PAL/Board
    ../../../../PAL/XMEGA/ATXMEGA256A3/Boards/REB_4_1_CBB/: pal_board.c pal_irq.c
  group Resources
    ../../../../Resources/Buffer_Management/Src/: bmm.c
    ../../../../Resources/Queue_Management/Src/: qmm.c
  group SAL
    ../../../../SAL/ATXMEGA_SAL/Src/: sal.c
  group STB
    ../../../../STB/Src/: stb.c stb_help.c
  group TAL
    ../../../../TAL/AT86RF231/Src/: tal.c tal_ed.c tal_init.c tal_irq_handler.c tal_pib.c tal_pwr_mgmt.c tal_rx.c tal_rx_enable.c tal_slotted_csma.c tal_tx.c
    ../../../../TAL/Src/: tal_ed_end_cb.c
