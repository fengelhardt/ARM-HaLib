# IAR project Secure_Remote_Control.ewp, settings and files
configuration Secure_Remote_Control (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3S4 Atmel AT91SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NOTRACE; DEBUG=0; SIO_HUB; USB0; TAL_TYPE=AT86RF212; PAL_TYPE=AT91SAM3S4C; PAL_GENERIC_TYPE=SAM3; BOARD_TYPE=RZ600_212_SAM3SEK; HIGHEST_STACK_LAYER=TAL; SAL_TYPE=AT86RF2xx; ENABLE_TRX_SRAM; STB_ON_SAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\Helper_Files\SIO_Support\Inc; ..\..\..\..\Include; ..\..\..\..\TAL\Inc; ..\..\..\..\TAL\AT86RF212\Inc; ..\..\..\..\PAL\Inc; ..\..\..\..\PAL\SAM3\Generic\Inc; ..\..\..\..\PAL\SAM3\Libraries; ..\..\..\..\PAL\SAM3\Libraries\cmsis; ..\..\..\..\PAL\SAM3\Libraries\usb\include; ..\..\..\..\PAL\SAM3\Libraries\usb\VCP\include; ..\..\..\..\PAL\SAM3\AT91SAM3S4C\Inc; ..\..\..\..\PAL\SAM3\AT91SAM3S4C\Boards; ..\..\..\..\PAL\SAM3\AT91SAM3S4C\Boards\RZ600_212_SAM3SEK; ..\..\..\..\PAL\SAM3\AT91SAM3S4C\Boards\RZ600_212_SAM3SEK\Descriptors; ..\..\..\..\Resources\Buffer_Management\Inc; ..\..\..\..\Resources\Queue_Management\Inc; ..\..\..\..\SAL\SW_AES_SAL\Inc; ..\..\..\..\SAL\Inc; ..\..\..\..\STB\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Secure_Remote_Control.bin
  ILINK.IlinkOutputFile: Secure_Remote_Control.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../Src/: main.c
    ../../../Helper_Files/SIO_Support/Src/: sio_handler.c
    ../../../Helper_Files/SIO_Support/IAR_Support/: write.c
  group PAL
    ../../../../PAL/SAM3/Generic/Src/: exceptions.c pal.c pal_timer.c pal_trx_access.c pal_uart.c pal_usb.c pal_utils.c
    ../../../../PAL/SAM3/AT91SAM3S4C/Src/: pal_sio_hub.c
  group PAL/Board
    ../../../../PAL/SAM3/AT91SAM3S4C/Boards/RZ600_212_SAM3SEK/: pal_board.c pal_irq.c
  group PAL/Libraries/usb
    ../../../../PAL/SAM3/Libraries/usb/src/: halUsb.c usb.c
    ../../../../PAL/SAM3/Libraries/usb/VCP/src/: vcpCdcProtocol.c vcpDescriptors.c vcpEnumeration.c vcpVirtualUsart.c
  group PAL/startup
    ../../../../PAL/SAM3/AT91SAM3S4C/Boards/RZ600_212_SAM3SEK/: board_cstartup_iar.c
  group Resources
    ../../../../Resources/Buffer_Management/Src/: bmm.c
    ../../../../Resources/Queue_Management/Src/: qmm.c
  group SAL
    ../../../../SAL/AT86RF2xx/Src/: sal.c
  group STB
    ../../../../STB/Src/: stb.c stb_help.c
  group TAL
    ../../../../TAL/AT86RF212/Src/: tal.c tal_ed.c tal_init.c tal_irq_handler.c tal_pib.c tal_pwr_mgmt.c tal_rx.c tal_rx_enable.c tal_slotted_csma.c tal_tx.c
