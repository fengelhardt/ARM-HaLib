# IAR project Sensor.ewp, settings and files
configuration Release (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x200
  General.SCRStackSize: 32
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-5s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3 ATxmega256A3
  ICCAVR.CCDefines: SIO_HUB; UART0; DEBUG=0; REDUCED_PARAM_CHECK; STB_ON_SAL; TAL_TYPE=AT86RF231; PAL_TYPE=ATXMEGA256A3; PAL_GENERIC_TYPE=XMEGA; BOARD_TYPE=REB_4_1_CBB; SAL_TYPE=ATXMEGA_SAL; HIGHEST_STACK_LAYER=MAC
  ICCAVR.newCCIncludePaths: ..\Inc; ..\..\Inc; ..\..\..\..\Helper_Files\SIO_Support\Inc; ..\..\..\..\..\Include; ..\..\..\..\..\PAL\Inc; ..\..\..\..\..\PAL\XMEGA\Generic\Inc; ..\..\..\..\..\PAL\XMEGA\ATXMEGA256A3\Inc; ..\..\..\..\..\PAL\XMEGA\ATXMEGA256A3\Boards; ..\..\..\..\..\PAL\XMEGA\ATXMEGA256A3\Boards\REB_4_1_CBB; ..\..\..\..\..\TAL\Inc; ..\..\..\..\..\TAL\AT86RF231\Inc; ..\..\..\..\..\MAC\Inc; ..\..\..\..\..\Resources\Queue_Management\Inc; ..\..\..\..\..\Resources\Buffer_Management\Inc; ..\..\..\..\..\SAL\Inc; ..\..\..\..\..\STB\Inc
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Debug (AVR, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  ICCAVR.CCDefines: SIO_HUB; UART0; DEBUG=1; REDUCED_PARAM_CHECK; STB_ON_SAL; TAL_TYPE=AT86RF231; PAL_TYPE=ATXMEGA256A3; PAL_GENERIC_TYPE=XMEGA; BOARD_TYPE=REB_4_1_CBB; SAL_TYPE=ATXMEGA_SAL; HIGHEST_STACK_LAYER=MAC
  group (top)
    ../Src/: main.c
    ../../../../Helper_Files/SIO_Support/Src/: sio_handler.c
    ../../Src/: stb_app_defs.c
    ../../../../Helper_Files/SIO_Support/IAR_Support/: write.c
  group MAC
    ../../../../../MAC/Src/: mac.c mac_associate.c mac_beacon.c mac_callback_wrapper.c mac_data_ind.c mac_data_req.c mac_disassociate.c mac_dispatcher.c mac_mcps_data.c mac_misc.c mac_orphan.c mac_pib.c mac_poll.c mac_process_beacon_frame.c mac_process_tal_tx_frame_status.c mac_rx_enable.c mac_scan.c mac_start.c mac_sync.c mac_tx_coord_realignment_command.c
  group MAC_API
    ../../../../../MAC/Src/: mac_api.c usr_mcps_data_ind.c usr_mcps_purge_conf.c usr_mlme_associate_ind.c usr_mlme_beacon_notify_ind.c usr_mlme_comm_status_ind.c usr_mlme_disassociate_conf.c usr_mlme_disassociate_ind.c usr_mlme_get_conf.c usr_mlme_orphan_ind.c usr_mlme_poll_conf.c usr_mlme_rx_enable_conf.c usr_mlme_set_conf.c usr_mlme_start_conf.c usr_mlme_sync_loss_ind.c
  group PAL
    ../../../../../PAL/XMEGA/Generic/Src/: pal.c pal_timer.c pal_trx_access.c pal_uart.c pal_utils.c
    ../../../../../PAL/XMEGA/ATXMEGA256A3/Src/: pal_sio_hub.c
  group PAL/Board
    ../../../../../PAL/XMEGA/ATXMEGA256A3/Boards/REB_4_1_CBB/: pal_board.c pal_irq.c
  group Resources
    ../../../../../Resources/Buffer_Management/Src/: bmm.c
    ../../../../../Resources/Queue_Management/Src/: qmm.c
  group SAL
    ../../../../../SAL/ATXMEGA_SAL/Src/: sal.c
  group STB
    ../../../../../STB/Src/: stb.c stb_help.c
  group TAL
    ../../../../../TAL/AT86RF231/Src/: tal.c tal_ed.c tal_init.c tal_irq_handler.c tal_pib.c tal_pwr_mgmt.c tal_rx.c tal_rx_enable.c tal_slotted_csma.c tal_tx.c
