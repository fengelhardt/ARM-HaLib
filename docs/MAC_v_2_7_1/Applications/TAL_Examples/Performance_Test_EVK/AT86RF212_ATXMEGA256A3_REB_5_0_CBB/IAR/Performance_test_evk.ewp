# IAR project Performance_test_evk.ewp, settings and files
configuration Release (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x200
  General.SCRStackSize: 32
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-5s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3 ATxmega256A3
  ICCAVR.CCDefines: DEBUG=0; FFD; HIGH_DATA_RATE_SUPPORT; ENABLE_TFA; SIO_HUB; UART0; TAL_TYPE=AT86RF212; PAL_TYPE=ATXMEGA256A3; PAL_GENERIC_TYPE=XMEGA; BOARD_TYPE=REB_5_0_CBB; HIGHEST_STACK_LAYER=TAL
  ICCAVR.newCCIncludePaths: ..\..\Inc; ..\..\..\..\Helper_Files\SIO_Support\Inc; ..\..\..\..\..\Include; ..\..\..\..\..\TAL\Inc; ..\..\..\..\..\TAL\AT86RF212\Inc; ..\..\..\..\..\TFA\Inc; ..\..\..\..\..\PAL\Inc; ..\..\..\..\..\PAL\XMEGA\Generic\Inc; ..\..\..\..\..\PAL\XMEGA\ATXMEGA256A3\Inc; ..\..\..\..\..\PAL\XMEGA\ATXMEGA256A3\Boards; ..\..\..\..\..\PAL\XMEGA\ATXMEGA256A3\Boards\REB_5_0_CBB; ..\..\..\..\..\Resources\Buffer_Management\Inc; ..\..\..\..\..\Resources\Queue_Management\Inc
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm256a3.xcl
configuration Debug (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: DEBUG=1; FFD; HIGH_DATA_RATE_SUPPORT; ENABLE_TFA; SIO_HUB; UART0; TAL_TYPE=AT86RF212; PAL_TYPE=ATXMEGA256A3; PAL_GENERIC_TYPE=XMEGA; BOARD_TYPE=REB_5_0_CBB; HIGHEST_STACK_LAYER=TAL
  group (top)
    ../../Src/: app_op_mode_1.c app_op_mode_2.c app_pairing.c main.c
    ../../../../Helper_Files/SIO_Support/Src/: sio_handler.c
    ../../../../Helper_Files/SIO_Support/IAR_Support/: write.c
  group PAL
    ../../../../../PAL/XMEGA/Generic/Src/: pal.c pal_timer.c pal_trx_access.c pal_uart.c pal_utils.c
    ../../../../../PAL/XMEGA/ATXMEGA256A3/Src/: pal_sio_hub.c
  group PAL/Board
    ../../../../../PAL/XMEGA/ATXMEGA256A3/Boards/REB_5_0_CBB/: pal_board.c pal_irq.c
  group Resources
    ../../../../../Resources/Buffer_Management/Src/: bmm.c
    ../../../../../Resources/Queue_Management/Src/: qmm.c
  group TAL
    ../../../../../TAL/AT86RF212/Src/: tal.c tal_ed.c tal_init.c tal_irq_handler.c tal_pib.c tal_pwr_mgmt.c tal_rx.c tal_rx_enable.c tal_slotted_csma.c tal_tx.c
  group TFA
    ../../../../../TFA/AT86RF212/Src/: tfa.c
