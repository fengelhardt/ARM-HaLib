# IAR project Performance_test_evk.ewp, settings and files
configuration Performance_test_evk (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3S4 Atmel AT91SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG=0; FFD; SIO_HUB; USB0; ENABLE_TFA; TAL_TYPE=AT86RF212; PAL_TYPE=AT91SAM3S4C; PAL_GENERIC_TYPE=SAM3; BOARD_TYPE=RZ600_212_SAM3SEK; HIGHEST_STACK_LAYER=TAL; PROMISCUOUS_MODE; HIGH_DATA_RATE_SUPPORT
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\Helper_Files\SIO_Support\Inc; ..\..\..\..\Include; ..\..\..\..\TAL\Inc; ..\..\..\..\TAL\AT86RF212\Inc; ..\..\..\..\TFA\Inc; ..\..\..\..\PAL\Inc; ..\..\..\..\PAL\SAM3\Generic\Inc; ..\..\..\..\PAL\SAM3\AT91SAM3S4C\Inc; ..\..\..\..\PAL\SAM3\AT91SAM3S4C\Boards; ..\..\..\..\PAL\SAM3\AT91SAM3S4C\boards\RZ600_212_SAM3SEK; ..\..\..\..\PAL\SAM3\AT91SAM3S4C\boards\RZ600_212_SAM3SEK\Descriptors; ..\..\..\..\PAL\SAM3\Libraries\cmsis; ..\..\..\..\PAL\SAM3\Libraries\usb\include; ..\..\..\..\PAL\SAM3\Libraries\usb\VCP\include; ..\..\..\..\PAL\SAM3\Libraries\; ..\..\..\..\Resources\Buffer_Management\Inc; ..\..\..\..\Resources\Queue_Management\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Performance_test_evk.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../Src/: app_op_mode_1.c app_op_mode_2.c app_pairing.c main.c
    ../../../Helper_Files/SIO_Support/Src/: sio_handler.c
    ../../../Helper_Files/SIO_Support/IAR_Support/: write.c
  group PAL
    ../../../../PAL/SAM3/Generic/Src/: exceptions.c pal.c pal_timer.c pal_trx_access.c pal_uart.c pal_usb.c pal_utils.c
    ../../../../PAL/SAM3/AT91SAM3S4C/Src/: pal_sio_hub.c
  group PAL/Board
    ../../../../PAL/SAM3/AT91SAM3S4C/Boards/RZ600_212_SAM3SEK/: pal_board.c pal_irq.c
  group PAL/Lib/cmsis
    ../../../../PAL/SAM3/Libraries/cmsis/: core_cm3.c
  group PAL/Lib/usb
    ../../../../PAL/SAM3/Libraries/usb/src/: halUsb.c usb.c
    ../../../../PAL/SAM3/Libraries/usb/VCP/src/: vcpCdcProtocol.c vcpDescriptors.c vcpEnumeration.c vcpVirtualUsart.c
  group PAL/startup
    ../../../../PAL/SAM3/AT91SAM3S4C/Boards/RZ600_212_SAM3SEK/: board_cstartup_iar.c
  group Resources
    ../../../../Resources/Buffer_Management/Src/: bmm.c
    ../../../../Resources/Queue_Management/Src/: qmm.c
  group TAL
    ../../../../TAL/AT86RF212/Src/: tal.c tal_ed.c tal_init.c tal_irq_handler.c tal_pib.c tal_pwr_mgmt.c tal_rx.c tal_rx_enable.c tal_slotted_csma.c tal_tx.c
  group TFA
    ../../../../TFA/AT86RF212/Src/: tfa.c
