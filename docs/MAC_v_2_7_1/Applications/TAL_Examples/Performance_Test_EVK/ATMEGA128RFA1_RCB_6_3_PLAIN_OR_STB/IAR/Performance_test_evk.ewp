# IAR project Performance_test_evk.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x200
  General.SCRStackSize: 32
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m128rfa1 ATmega128RFA1
  ICCAVR.CCDefines: DEBUG=0; FFD; HIGH_DATA_RATE_SUPPORT; ENABLE_TFA; SIO_HUB; USB0; TAL_TYPE=ATMEGARF_TAL_1; PAL_TYPE=ATMEGA128RFA1; PAL_GENERIC_TYPE=MEGA_RF; BOARD_TYPE=RCB_6_3_PLAIN_OR_STB; HIGHEST_STACK_LAYER=TAL
  ICCAVR.newCCIncludePaths: ..\..\Inc; ..\..\..\..\Helper_Files\SIO_Support\Inc; ..\..\..\..\..\Include; ..\..\..\..\..\TAL\Inc; ..\..\..\..\..\TAL\ATMEGARF_TAL_1\Inc; ..\..\..\..\..\TFA\Inc; ..\..\..\..\..\PAL\Inc; ..\..\..\..\..\PAL\MEGA_RF\Generic\Inc; ..\..\..\..\..\PAL\MEGA_RF\ATMEGA128RFA1\Inc; ..\..\..\..\..\PAL\MEGA_RF\ATMEGA128RFA1\Boards; ..\..\..\..\..\PAL\MEGA_RF\ATMEGA128RFA1\Boards\RCB_6_3_PLAIN_OR_STB; ..\..\..\..\..\Resources\Buffer_Management\Inc; ..\..\..\..\..\Resources\Queue_Management\Inc
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128rfa1.xcl
configuration Release (AVR)
  as the first configuration, except:
  group (top)
    ../../Src/: app_op_mode_1.c app_op_mode_2.c app_pairing.c main.c
    ../../../../Helper_Files/SIO_Support/Src/: sio_handler.c
    ../../../../Helper_Files/SIO_Support/IAR_Support/: write.c
  group PAL
    ../../../../../PAL/MEGA_RF/Generic/Src/: pal.c pal_uart.c pal_utils.c
    ../../../../../PAL/MEGA_RF/ATMEGA128RFA1/Src/: pal_mcu_generic.c pal_sio_hub.c pal_timer.c pal_usb_ftdi.c
  group PAL/Board
    ../../../../../PAL/MEGA_RF/ATMEGA128RFA1/Boards/RCB_6_3_PLAIN_OR_STB/: pal_board.c
    ../../../../../PAL/MEGA_RF/ATMEGA128RFA1/Src/: pal_irq.c
  group Resources
    ../../../../../Resources/Buffer_Management/Src/: bmm.c
    ../../../../../Resources/Queue_Management/Src/: qmm.c
  group TAL
    ../../../../../TAL/ATMEGARF_TAL_1/Src/: tal.c tal_ed.c tal_init.c tal_irq_handler.c tal_pib.c tal_pwr_mgmt.c tal_rx.c tal_rx_enable.c tal_slotted_csma.c tal_tx.c
  group TFA
    ../../../../../TFA/ATMEGARF_TAL_1/Src/: tfa.c
