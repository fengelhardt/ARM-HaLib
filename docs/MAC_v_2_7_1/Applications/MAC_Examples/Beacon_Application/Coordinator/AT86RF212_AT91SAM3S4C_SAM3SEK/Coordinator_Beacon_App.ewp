# IAR project Coordinator_Beacon_App.ewp, settings and files
configuration Coordinator (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3S4 Atmel AT91SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG=0; NOASSERT; TRACE_LEVEL=0; SIO_HUB; USB0; TAL_TYPE=AT86RF212; PAL_TYPE=AT91SAM3S4C; PAL_GENERIC_TYPE=SAM3; BOARD_TYPE=RZ600_212_SAM3SEK; FFD; BEACON_SUPPORT; DISABLE_TSTAMP_IRQ; REDUCED_PARAM_CHECK; HIGHEST_STACK_LAYER=MAC
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\Helper_Files\SIO_Support\Inc; ..\..\..\..\..\Include; ..\..\..\..\..\PAL\Inc; ..\..\..\..\..\PAL\SAM3\Generic\Inc; ..\..\..\..\..\PAL\SAM3\AT91SAM3S4C\Inc; ..\..\..\..\..\PAL\SAM3\AT91SAM3S4C\Boards; ..\..\..\..\..\PAL\SAM3\AT91SAM3S4C\boards\RZ600_212_SAM3SEK; ..\..\..\..\..\PAL\SAM3\AT91SAM3S4C\boards\RZ600_212_SAM3SEK\Descriptors; ..\..\..\..\..\PAL\SAM3\Libraries\usb\include; ..\..\..\..\..\PAL\SAM3\Libraries\usb\VCP\include; ..\..\..\..\..\PAL\SAM3\Libraries\cmsis; ..\..\..\..\..\PAL\SAM3\Libraries\; ..\..\..\..\..\MAC\Inc; ..\..\..\..\..\TAL\Inc; ..\..\..\..\..\TAL\AT86RF212\Inc; ..\..\..\..\..\Resources\Queue_Management\Inc; ..\..\..\..\..\Resources\Buffer_Management\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\PAL\ARM7\AT91SAM7X256\Inc
  OBJCOPY.OOCOutputFile: Coordinator_Beacon_App.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../Src/: main.c
    ../../../../Helper_Files/SIO_Support/Src/: sio_handler.c
    ../../../../Helper_Files/SIO_Support/IAR_Support/: write.c
  group MAC
    ../../../../../MAC/Src/: mac.c mac_associate.c mac_beacon.c mac_callback_wrapper.c mac_data_ind.c mac_data_req.c mac_disassociate.c mac_dispatcher.c mac_mcps_data.c mac_misc.c mac_orphan.c mac_pib.c mac_poll.c mac_process_beacon_frame.c mac_process_tal_tx_frame_status.c mac_rx_enable.c mac_scan.c mac_start.c mac_sync.c mac_tx_coord_realignment_command.c
  group MAC_API
    ../../../../../MAC/Src/: mac_api.c usr_mcps_purge_conf.c usr_mlme_associate_conf.c usr_mlme_beacon_notify_ind.c usr_mlme_disassociate_conf.c usr_mlme_disassociate_ind.c usr_mlme_get_conf.c usr_mlme_orphan_ind.c usr_mlme_poll_conf.c usr_mlme_rx_enable_conf.c usr_mlme_sync_loss_ind.c
  group PAL
    ../../../../../PAL/SAM3/Generic/Src/: exceptions.c pal.c pal_timer.c pal_trx_access.c pal_uart.c pal_usb.c pal_utils.c
    ../../../../../PAL/SAM3/AT91SAM3S4C/Src/: pal_sio_hub.c
  group PAL/Board
    ../../../../../PAL/SAM3/AT91SAM3S4C/Boards/RZ600_212_SAM3SEK/: pal_board.c pal_irq.c
  group PAL/Lib
    ../../../../../PAL/SAM3/Libraries/cmsis/: core_cm3.c
  group PAL/Lib/usb
    ../../../../../PAL/SAM3/Libraries/usb/src/: halUsb.c usb.c
    ../../../../../PAL/SAM3/Libraries/usb/VCP/src/: vcpCdcProtocol.c vcpDescriptors.c vcpEnumeration.c vcpVirtualUsart.c
  group PAL/startup
    ../../../../../PAL/SAM3/AT91SAM3S4C/Boards/RZ600_212_SAM3SEK/: board_cstartup_iar.c
  group Resources
    ../../../../../Resources/Buffer_Management/Src/: bmm.c
    ../../../../../Resources/Queue_Management/Src/: qmm.c
  group TAL
    ../../../../../TAL/AT86RF212/Src/: tal.c tal_ed.c tal_init.c tal_irq_handler.c tal_pib.c tal_pwr_mgmt.c tal_rx.c tal_rx_enable.c tal_slotted_csma.c tal_tx.c
