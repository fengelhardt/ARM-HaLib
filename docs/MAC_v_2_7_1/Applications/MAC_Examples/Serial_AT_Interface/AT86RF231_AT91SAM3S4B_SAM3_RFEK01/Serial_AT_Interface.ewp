# IAR project Serial_AT_Interface.ewp, settings and files
configuration Serial_AT_Interface (ARM)
  General.OGChipSelectEditMenu: AT91SAM3S4 Atmel AT91SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG=0; SIO_HUB; USB0; TAL_TYPE=AT86RF231; PAL_TYPE=AT91SAM3S4B; PAL_GENERIC_TYPE=SAM3; BOARD_TYPE=SAM3_RFEK01; HIGHEST_STACK_LAYER=MAC; IEEE_ADDR=0x123456789ABCDEF0; FFD; BEACON_SUPPORT; ENABLE_TSTAMP
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\Helper_Files\SIO_Support\Inc; ..\..\..\..\Include; ..\..\..\..\PAL\Inc; ..\..\..\..\PAL\SAM3\Generic\Inc; ..\..\..\..\PAL\SAM3\Libraries; ..\..\..\..\PAL\SAM3\Libraries\cmsis; ..\..\..\..\PAL\SAM3\Libraries\usb\include; ..\..\..\..\PAL\SAM3\Libraries\usb\VCP\include; ..\..\..\..\PAL\SAM3\AT91SAM3S4B\Inc; ..\..\..\..\PAL\SAM3\AT91SAM3S4B\Boards; ..\..\..\..\PAL\SAM3\AT91SAM3S4B\Boards\SAM3_RFEK01; ..\..\..\..\PAL\SAM3\AT91SAM3S4B\Boards\SAM3_RFEK01\Descriptors; ..\..\..\..\TAL\Inc; ..\..\..\..\TAL\AT86RF231\Inc; ..\..\..\..\MAC\Inc; ..\..\..\..\Resources\Queue_Management\Inc; ..\..\..\..\Resources\Buffer_Management\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Serial_AT_Interface.bin
  ILINK.IlinkOutputFile: AT_Command_Interface.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group MAC
    ../../../../MAC/Src/: mac.c mac_api.c mac_associate.c mac_beacon.c mac_callback_wrapper.c mac_data_ind.c mac_data_req.c mac_disassociate.c mac_dispatcher.c mac_mcps_data.c mac_misc.c mac_orphan.c mac_pib.c mac_poll.c mac_process_beacon_frame.c mac_process_tal_tx_frame_status.c mac_rx_enable.c mac_scan.c mac_start.c mac_sync.c mac_tx_coord_realignment_command.c
  group PAL
    ../../../../PAL/SAM3/Generic/Src/: exceptions.c pal.c pal_timer.c pal_trx_access.c pal_uart.c pal_usb.c pal_utils.c
    ../../../../PAL/SAM3/AT91SAM3S4B/Src/: pal_sio_hub.c
  group PAL/Board
    ../../../../PAL/SAM3/AT91SAM3S4B/Boards/SAM3_RFEK01/: pal_board.c pal_irq.c
  group PAL/Lib/usb
    ../../../../PAL/SAM3/Libraries/usb/src/: halUsb.c usb.c
    ../../../../PAL/SAM3/Libraries/usb/VCP/src/: vcpCdcProtocol.c vcpDescriptors.c vcpEnumeration.c vcpVirtualUsart.c
  group PAL/Startup
    ../../../../PAL/SAM3/AT91SAM3S4B/Boards/SAM3_RFEK01/: board_cstartup_iar.c
  group Resources
    ../../../../Resources/Buffer_Management/Src/: bmm.c
    ../../../../Resources/Queue_Management/Src/: qmm.c
  group Serial_AT_Interface
    ../Src/: cmd_handler.c cmd_parser.c main.c rsp_handler.c sio_handler.c
  group TAL
    ../../../../TAL/AT86RF231/Src/: tal.c tal_ed.c tal_init.c tal_irq_handler.c tal_pib.c tal_pwr_mgmt.c tal_rx.c tal_rx_enable.c tal_slotted_csma.c tal_tx.c
