# IAR project Boot_from_ROM.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: AT91SAM3S4 Atmel AT91SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TAL_TYPE=AT86RF212; PAL_TYPE=AT91SAM3S4B; PAL_GENERIC_TYPE=SAM3; BOARD_TYPE=SAM3_RFEK02; HIGHEST_STACK_LAYER=PAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\Include; ..\..\..\..\PAL\Inc; ..\..\..\..\PAL\SAM3\Generic\Inc; ..\..\..\..\PAL\SAM3\AT91SAM3S4B\Inc; ..\..\..\..\PAL\SAM3\AT91SAM3S4B\Boards; ..\..\..\..\PAL\SAM3\AT91SAM3S4B\boards\SAM3_RFEK02; ..\..\..\..\PAL\SAM3\Libraries\cmsis; ..\..\..\..\PAL\SAM3\Libraries\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Boot_from_ROM.bin
  ILINK.IlinkOutputFile: Boot_from_ROM.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../Src/: main.c
